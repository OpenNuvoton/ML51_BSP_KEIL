# Keil uVision project LPR_UART2.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: LPR_UART2 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: LPR_UART2.c
  group Library
    ../../../../Library/StdDriver/src/: common.c lowpwer.c pdma.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
