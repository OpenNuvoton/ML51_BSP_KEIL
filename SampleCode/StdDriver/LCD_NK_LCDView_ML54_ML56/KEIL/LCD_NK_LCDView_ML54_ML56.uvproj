# Keil uVision project LCD_NK_LCDView_ML54_ML56.uvproj, settings and files
target LCD_NK_LCDView_ML54_ML56 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LCD_NK_LCDView_ML54_ML56 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group LCD
    ../: lcd_nk.c lcdview.c
  group Temperature
    ../: adc_vtemp.c
  group Common
    ../../../../Library/StdDriver/src/: common.c lcd.c rtc.c adc.c vref.c delay.c
