# Keil uVision project LCD_NK_LCDView.uvproj, settings and files
target NK_ML56SD_LCD_View (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: NK_ML56SD +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: LCD_NK_LCDView_Main.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group LCD
    ../: LCDView.c LCD_NK.c
  group Temperature
    ../: ADC_VTEMP.C
  group Common
    ../../../../Library/StdDriver/src/: common.c lcd.c rtc.c adc.c vref.c delay.c
