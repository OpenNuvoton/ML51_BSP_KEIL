# Keil uVision project IAP_Dataflash_EEPROM_SPROM_Array.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_Dataflash_EEPROM_SPROM_Array +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: IAP_EEPROM_SPROM.c
  group Library
    ../../../../Library/StdDriver/src/: common.c eeprom_sprom.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
