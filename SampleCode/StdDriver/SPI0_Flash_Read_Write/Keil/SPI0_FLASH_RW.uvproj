# Keil uVision project SPI0_FLASH_RW.uvproj, settings and files
target StdDriver (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: SPI_Flash_RW +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: SPI0_Flash_RW.c
  group Library
    ../../../../Library/StdDriver/src/: common.c spi.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
