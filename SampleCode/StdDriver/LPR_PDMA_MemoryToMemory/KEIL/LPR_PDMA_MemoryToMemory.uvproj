# Keil uVision project LPR_PDMA_MemoryToMemory.uvproj, settings and files
target LPR_PDMA_MemoryToMemory (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: LPR_PDMA_MemoryToMemory +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: common.c lowpwer.c pdma.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
