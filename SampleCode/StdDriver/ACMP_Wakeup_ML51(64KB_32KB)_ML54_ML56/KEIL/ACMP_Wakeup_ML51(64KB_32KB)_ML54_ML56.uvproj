# Keil uVision project ACMP_Wakeup_ML51(64KB_32KB)_ML54_ML56.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ACMP_Wakeup_ML51(64KB_32KB)_ML54_ML56 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ACMP_Wake.c
  group Library
    ../../../../Library/StdDriver/src/: acmp.c common.c delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
