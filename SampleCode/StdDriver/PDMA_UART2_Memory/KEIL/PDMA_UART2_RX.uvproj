# Keil uVision project PDMA_UART2_RX.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: PDMA_UART2_MEM +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: PDMA_UART2_RX.c
  group Library
    ../../../../Library/StdDriver/src/: pdma.c uart.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
