# Keil uVision project IAP_LDROM_program_APROM.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_LDROM_program_APROM +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: IAP_LDproAP.c
  group Library
    ../../../../Library/StdDriver/src/: common.c IAP.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
