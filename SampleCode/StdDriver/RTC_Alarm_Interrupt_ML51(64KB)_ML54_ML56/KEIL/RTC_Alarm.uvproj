# Keil uVision project RTC_Alarm.uvproj, settings and files
target Target (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: RTC_Alarm +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: RTC_Alarm.C
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c rtc.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
