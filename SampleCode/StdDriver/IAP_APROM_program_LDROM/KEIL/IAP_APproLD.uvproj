# Keil uVision project IAP_APproLD.uvproj, settings and files
target Target1 (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_APproLD +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: IAP_APproLD.c
  group Library
    ../../../../Library/StdDriver/src/: common.c IAP.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
