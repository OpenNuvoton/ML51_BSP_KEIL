# Keil uVision project LPR_PWM0.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: LPR_PWM0 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: LPR_PWM.c
  group Library
    ../../../../Library/StdDriver/src/: common.c pwm0.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
