# Keil uVision project IAP_Read_UCID.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: IAP_Read_UCID +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Common;..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: UCID_check.C
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group Common
    ../../../../Library/StdDriver/src/: uart.c common.c IAP.c
