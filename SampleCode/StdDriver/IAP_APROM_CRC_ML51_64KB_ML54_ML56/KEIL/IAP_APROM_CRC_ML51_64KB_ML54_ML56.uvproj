# Keil uVision project IAP_APROM_CRC_ML51_64KB_ML54_ML56.uvproj, settings and files
target IAP_APROM_CRC_ML51_64KB_ML54_ML56 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_APROM_CRC_ML51_64KB_ML54_ML56 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c IAP.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
