# Keil uVision project Watchdog_Interrupt.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: Watchdog_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: WDT_LIB.c
  group Common
    ../../../../Library/StdDriver/src/: common.c wdt.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
