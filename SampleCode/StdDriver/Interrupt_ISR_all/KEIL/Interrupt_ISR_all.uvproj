# Keil uVision project Interrupt_ISR_all.uvproj, settings and files
target GPIO (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: Interrupt_ISR_all +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ISR_main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c isr.c
    ../../../../Library/Device/Source/: ML51_XSFR.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
