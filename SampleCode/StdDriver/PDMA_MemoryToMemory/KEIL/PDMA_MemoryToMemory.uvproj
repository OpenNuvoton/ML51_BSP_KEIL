# Keil uVision project PDMA_MemoryToMemory.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: PDMA_MemoryToMemory +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: PDMA_M2M.c
  group Library
    ../../../../Library/StdDriver/src/: common.c pdma.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
