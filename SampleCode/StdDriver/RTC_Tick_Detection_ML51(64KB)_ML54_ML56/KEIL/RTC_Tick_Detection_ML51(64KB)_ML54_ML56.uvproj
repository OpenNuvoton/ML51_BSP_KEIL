# Keil uVision project RTC_Tick_Detection_ML51(64KB)_ML54_ML56.uvproj, settings and files
target Target (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: RTC_Tick_Detection_ML51(64KB)_ML54_ML56 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: RTC_Tick_Detection.C
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c rtc.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
