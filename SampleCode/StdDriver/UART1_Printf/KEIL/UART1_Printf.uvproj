# Keil uVision project UART1_Printf.uvproj, settings and files
target UART1_Printf (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: UART1_Printf +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c putchar.c
  group Common
    ../../../../Library/StdDriver/src/: uart.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
