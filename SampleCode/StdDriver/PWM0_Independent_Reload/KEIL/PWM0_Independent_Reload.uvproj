# Keil uVision project PWM0_Independent_Reload.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: PWM0_Independent +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: PWM0_Independent_reload.c
  group Library
    ../../../../Library/StdDriver/src/: common.c pwm0.c delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
