# Keil uVision project ISP_UART1.uvproj, settings and files
target Regbased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ISP_UART1 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\ISP_UART1
  link misc: REMOVEUNUSED
  group Source
    ../: ISP_UART1_main_autosize.c isp_uart1.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
