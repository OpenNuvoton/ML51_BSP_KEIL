# Keil uVision project ISP_UART2.uvproj, settings and files
target Regbased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ISP_UART2 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\ISP_UART2
  link misc: REMOVEUNUSED
  group Source
    ../: ISP_uart2_main.c
  group Common
    ../: isp_uart2.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
