# Keil uVision project ISP_I2C0.uvproj, settings and files
target ISP (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ISP_I2C0 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ISP_I2C_main_autosize_wdtdis.c ISP_I2C.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
