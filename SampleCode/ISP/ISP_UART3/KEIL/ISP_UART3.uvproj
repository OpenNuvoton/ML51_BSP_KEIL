# Keil uVision project ISP_UART3.uvproj, settings and files
target ISP_UART3 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ISP_UART3 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\ISP_UART2
  link misc: REMOVEUNUSED
  group Source
    ../: main.c isp_uart3.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
