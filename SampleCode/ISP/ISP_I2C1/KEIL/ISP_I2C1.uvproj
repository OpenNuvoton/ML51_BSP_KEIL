# Keil uVision project ISP_I2C1.uvproj, settings and files
target ISP_I2C1 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ISP_I2C1 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\ISP_UART1
  link misc: REMOVEUNUSED
  group Source
    ../: main.c isp_i2c1.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
