# Keil uVision project GPIO_INT0_Interrupt.uvproj, settings and files
target RegBased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: GPIO_INT0_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: INT0.C
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c IAP.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
