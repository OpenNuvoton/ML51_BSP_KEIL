# Keil uVision project I2C0_SLave_Mask.uvproj, settings and files
target I2C_EEPROM (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: I2C0_SLave_Mask +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: I2C_Device.c
  group Library
    ../../../../Library/StdDriver/src/: common.c i2c.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
