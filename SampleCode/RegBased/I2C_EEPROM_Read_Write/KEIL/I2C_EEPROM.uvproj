# Keil uVision project I2C_EEPROM.uvproj, settings and files
target Regbased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: I2C_EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: I2C_EEPROM.c
  group Common
    ../../../../Library/StdDriver/src/: uart.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
