# Keil uVision project ADC_PWM_Trig.uvproj, settings and files
target ADC_PWM_Trig (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ADC_PWM_Trig +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
