# Keil uVision project ADC_VTEMP.uvproj, settings and files
target RegBased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ADC_VTEMP +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ADC_VTEMP.C
  group Library
    ../../../../Library/StdDriver/src/: common.c uart.c vref.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
