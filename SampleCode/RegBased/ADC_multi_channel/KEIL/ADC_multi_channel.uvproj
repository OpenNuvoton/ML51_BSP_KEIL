# Keil uVision project ADC_multi_channel.uvproj, settings and files
target ADC_multi_channel (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ADC_multi_channel +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
