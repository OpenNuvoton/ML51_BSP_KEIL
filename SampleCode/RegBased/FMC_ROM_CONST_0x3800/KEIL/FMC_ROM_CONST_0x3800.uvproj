# Keil uVision project FMC_ROM_CONST_0x3800.uvproj, settings and files
target RegBased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: FMC_ROM_CONST_0x3800 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Table_Address.c Table_Data .c ROM_const.c
  group Common
    ../../../../Library/StdDriver/src/: common.c Delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
