# Keil uVision project ROM_CONST.uvproj, settings and files
target Regbased (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ROM_CONST +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Table_Address.c Table_Data .c ROM_const.c
  group Common
    ../../../../Library/StdDriver/src/: common.c Delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
