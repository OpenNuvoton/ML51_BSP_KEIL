# Keil uVision project NuMaker_TK_PowerDown_ML56.uvproj, settings and files
target NuMaker_TK_PowerDown_ML56 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: NuMaker_TK_PowerDown_ML56 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c define: DEMO_FREERUN BOARD_NUMAKER MASS_FINETUNE
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib
  link misc: REMOVEUNUSED
  group Source
    ../: main.c TK_SysTick.c TK_Led.c TK_Data.c TK_DebugUART.c TK_MassProduction.c TK_UartCmd.c TK_MultPinFunctions.c
  group Library
    ../../../../Library/StdDriver/src/: common.c
    ../../../../Library/StdDriver/lib/: TKLib_MassProduction_LX51.LIB
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group RTC
    ../../../../Library/StdDriver/src/: rtc.c
