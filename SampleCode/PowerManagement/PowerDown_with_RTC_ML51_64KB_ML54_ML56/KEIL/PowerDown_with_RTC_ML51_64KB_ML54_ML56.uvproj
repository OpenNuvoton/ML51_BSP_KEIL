# Keil uVision project PowerDown_with_RTC_ML51_64KB_ML54_ML56.uvproj, settings and files
target PowerDown_with_RTC_ML51_64KB_ML54_ML56 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: PowerDown_with_RTC_ML51_64KB_ML54_ML56 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: common.c rtc.c delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
