# Keil uVision project NK_ML56SD_LCDTKView.uvproj, settings and files
target NK_ML56SD_LCDTKView (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: NK_ML56SD_LCDTKView +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c define: DEMO_FREERUN BOARD_NUMAKER MASS_FINETUNE
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib;..\..\..\..\Library\LCDLib;..\..\..\..\Library\TKlib
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: main.c tk_data.c tk_debuguart.c tk_led.c tk_massproduction.c tk_multpinfunctions.c tk_systik.c tk_uartcmd.c
  group TK_Library
    ../../../../Library/TKlib/: TKLib_MassProduction_LX51.LIB
  group LCD
    ../../../../Library/StdDriver/src/: lcd.c
    ../../../../Library/LCDLib/: lcdlib.c
    ../: lcdmain_nk.c
  group RTC
    ../../../../Library/StdDriver/src/: rtc.c
  group Temperature
    ../: adc_vtemp.c
    ../../../../Library/StdDriver/src/: adc.c vref.c
  group Common
    ../../../../Library/StdDriver/src/: common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
target TK_Calibration (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: as above
  output: NK_ML56SD_LCDTKView +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: DEMO_CALIBRATION BOARD_NUMAKER CAL_UART0
  c include: as above
  link misc: REMOVEUNUSED
