# Keil uVision project TouchKey.uvproj, settings and files
target TK_Calibration (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: TK_Calibration +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: DEMO_CALIBRATION BOARD_NUMAKER MASS_FINETUNE
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib
  link misc: REMOVEUNUSED
  group Source Group 1
    ../../../../Library/StdDriver/src/: common.c
    ../: TK_MultPinFunctions.c TK_SysTick.c TK_Led.c TK_Main.c TK_Data.c TK_DebugUART.c TK_MassProduction.c TK_UartCmd.c
  group Library
    ../../../../Library/StdDriver/lib/: TKLib_Calibration_LX51.LIB TKLib_FreeRun_LX51.LIB TKLib_MassProduction_LX51.LIB
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group Temperature
    ../: ADC_VTEMP.C
    ../../../../Library/StdDriver/src/: adc.c vref.c
  group LCD
    ../: LCDmain_NK.c LCDSub_Panel.c LCDSubCommon.c
    ../../../../Library/StdDriver/src/: lcd.c
  group RTC
    ../../../../Library/StdDriver/src/: rtc.c
target NK_ML56SD (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: as above
  output: NK_ML56SD +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c define: DEMO_FREERUN BOARD_NUMAKER MASS_FINETUNE
  c include: as above
  link misc: REMOVEUNUSED
