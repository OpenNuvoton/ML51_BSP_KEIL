# Keil uVision project NK_ML56SD_PD_LCDVIEW.uvproj, settings and files
target NK_ML56SD_PD_LCDVIEW (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: NK_ML56SD_PD_LCDVIEW +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c define: DEMO_FREERUN BOARD_NUMAKER MASS_FINETUNE
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib
  link misc: REMOVEUNUSED
  group Source
    ../: main.c TK_MultPinFunctions.c TK_SysTick.c TK_Led.c TK_Data.c TK_DebugUART.c TK_MassProduction.c TK_UartCmd.c TK_Flash.c
  group Library
    ../../../../Library/StdDriver/lib/: TKLib_Calibration_LX51.LIB TKLib_FreeRun_LX51.LIB TKLib_MassProduction_LX51.LIB
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group Temperature
    ../../../../Library/StdDriver/src/: adc.c vref.c
    ../: adc_vtemp.c
  group LCD
    ../../../../Library/StdDriver/src/: lcd.c
    ../: lcdmain_nk.c lcdview.c
  group RTC
    ../../../../Library/StdDriver/src/: rtc.c
  group Common
    ../../../../Library/StdDriver/src/: common.c
target TK_Calibration (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: as above
  output: TK_Calibration +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: DEMO_CALIBRATION BOARD_NUMAKER MASS_FINETUNE CAL_UART0
  c include: as above
  link misc: REMOVEUNUSED
